## drivers/soc/oplus/system/rt_info/Kconfig
```kconfig
config OPLUS_FEATURE_RT_INFO
	tristate "rt info stat"
	default n
	help
		Schedule info statistics for render thread
```
